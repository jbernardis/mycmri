File: kicad/dccsniffer/dccsniffer.kicad_sch (KiCad schematic)
At the start: 14 parts, among them J1 , U1 6N137

Commit message: long overdue update
Parts:
- J1: value (none) -> (none)
